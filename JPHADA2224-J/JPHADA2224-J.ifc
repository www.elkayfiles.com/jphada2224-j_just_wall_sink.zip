Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-02-08T14:36:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 08 14:36:59 2024 * Host: ZIL5CD2317NJM * Database: C:\Users\MKhan\AppData\Local\Temp\620f2077-0fbf-4177-a3f6-d549581d058d\603ff593-b65b-45ea-acdd-51e52d44e5b0\ifc * Database version: 5507 * Database creation date: Thu Feb 08 14:36:57 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Feb 08 14:36:57 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 08 14:36:57 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:1/4" Head (2)
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (ft)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 10

# IfcFlowTerminal: JPHADA2224-J_2:JPHADA2224-J_2, JPHADA2224-J_2:JPHADA2224-J_2:814245
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: JPHADA2224-J_2
Pset_DistributionFlowElementCommon - Reference: JPHADA2224-J_2; sets with these values: 2

# IfcFlowTerminal: LKB722C_1:LKB722C, LKB722C_1:LKB722C:814246
In: Level 2
Type - Material: Metal - Brass - Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: Elkay Powered Wall Mount Faucet Chrome
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: LKB722C
Pset_DistributionFlowElementCommon - Reference: LKB722C; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
Pset_ProductRequirements - sets with these values: 2
